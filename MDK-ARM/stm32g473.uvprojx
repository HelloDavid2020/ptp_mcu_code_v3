# Keil uVision project stm32g473.uvprojx, settings and files
target stm32g473 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G473VCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32g473 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G473xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;                ../Drivers/STM32G4xx_HAL_Driver/Inc;                ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                ../Drivers/CMSIS/Include;                ..\BSP;                ..\Lib;                ..\AT_COMMAND
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dac.c iwdg.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group BSP
    ../BSP/: board.c test.c event.c lcd.c lcd.h
  group Lib
    ../Lib/: lib_ringbuffer.c lib_commfunc.c
  group AT_COMMANDS
    ../AT_COMMAND/: at_cmds.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_tim.c stm32g4xx_ll_gpio.c stm32g4xx_ll_dma.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group ReadMe
    ../: README.md
software components: CMSIS:CORE 4.3.0
